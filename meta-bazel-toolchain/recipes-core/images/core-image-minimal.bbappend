inherit bazel_toolchain_patch
